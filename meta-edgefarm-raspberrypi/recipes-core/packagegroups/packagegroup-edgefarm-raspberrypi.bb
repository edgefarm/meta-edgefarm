SUMMARY = "edgefarm raspberrypi specific package groups"
DESCRIPTION = "This provides edgefarm raspberrypi specific package groups to enable edgefarm functionality on a raspberrypi device"

inherit packagegroup

PACKAGES = "\
    packagegroup-edgefarm-raspberrypi \
    "

RDEPENDS_packagegroup-edgefarm-raspberrypi = "\
    "
